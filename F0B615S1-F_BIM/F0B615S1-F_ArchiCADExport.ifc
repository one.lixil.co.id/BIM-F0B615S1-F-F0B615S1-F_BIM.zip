Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-12-20T20:11:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 20 20:11:51 2022 * Host: DESKTOP-D2DSTPK * Database: C:\Users\WINDOWS\AppData\Local\Temp\b1f4bab5-76b2-469f-8166-1cc850773c47\6d63769e-78fa-4738-b9e4-3eb0fc508978\ifc * Database version: 5507 * Database creation date: Tue Dec 20 20:11:45 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 20 20:11:46 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 20 20:11:46 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: F0B615S1-F_REVIT:S200 Rain Shower System W 5-Func HS, F0B615S1-F_REVIT:S200 Rain Shower System W 5-Func HS:347259
In: Level 1
Material: Plastic, Brass
Pset_DistributionFlowElementCommon - Reference: S200 Rain Shower System W 5-Func HS; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
